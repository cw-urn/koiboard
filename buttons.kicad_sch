File: buttons.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: BOM
Parts:
- BOOT1, RST1: LCSC (none) -> C455262
- R3, R4, R5: LCSC (none) -> C25905
- R6: LCSC (none) -> C11702
